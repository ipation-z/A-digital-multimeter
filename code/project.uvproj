# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c delay.c delay.h OLED.c OLED.h OLED_Font.h Timer0.c Timer0.h Key.c Key.h CD4051.c CD4051.h DCV.c DCV.h RES.c RES.h I2C.c I2C.h AD.c AD.h FREQ.c FREQ.h Buzzer.c Buzzer.h
